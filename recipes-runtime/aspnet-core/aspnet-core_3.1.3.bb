###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 3.1.3 ASP .Net Core runtime.
# Copyright Richard Dunkley 2020
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_3.1.3.inc
require recipes-runtime/aspnet-core/aspnet-core_3.x.x.inc
