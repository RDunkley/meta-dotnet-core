###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 2.2.8 ASP .Net Core runtime.
# Copyright Matthijs de Ridder 2019
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_2.2.8.inc
require recipes-runtime/aspnet-core/aspnet-core_2.x.x.inc
