###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.12 ASP .Net runtime.
# Copyright Sequent Logic 2022
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_6.0.12.inc
require recipes-runtime/aspnet-core/aspnet-core_6.x.x.inc
