###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 5.0.17 ASP .Net Core runtime.
# Copyright Sequent Logic 2023
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_5.0.17.inc
require recipes-runtime/aspnet-core/aspnet-core_5.x.x.inc
