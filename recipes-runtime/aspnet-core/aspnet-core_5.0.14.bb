###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 5.0.14 ASP .Net Core runtime.
# Copyright Richard Dunkley 2022
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_5.0.14.inc
require recipes-runtime/aspnet-core/aspnet-core_5.x.x.inc
