###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 8.0.19 ASP .Net runtime.
# Copyright JvZ 2025
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_8.0.19.inc
require recipes-runtime/aspnet-core/aspnet-core_8.x.x.inc

