###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 3.0.0 ASP .Net Core runtime.
# Copyright Richard Dunkley 2019
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_3.0.0.inc
require recipes-runtime/aspnet-core/aspnet-core_3.x.x.inc

