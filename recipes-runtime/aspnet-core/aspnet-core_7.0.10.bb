###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 7.0 ASP .Net runtime.
# Copyright Sequent Logic 2023
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_7.0.10.inc
require recipes-runtime/aspnet-core/aspnet-core_7.x.x.inc
