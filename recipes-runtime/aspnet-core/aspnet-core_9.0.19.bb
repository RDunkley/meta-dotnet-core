###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 9.0.19 ASP .Net runtime.
# Copyright Sequent Logic, LLC 2026
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-runtime/aspnet-core/aspnet-core_9.0.19.inc
require recipes-runtime/aspnet-core/aspnet-core_9.x.x.inc

