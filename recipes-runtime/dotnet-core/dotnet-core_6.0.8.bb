###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.8 .Net runtime.
# Copyright Sequent Logic 2022
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_6.0.8.inc
require recipes-runtime/dotnet-core/dotnet-core_6.x.x.inc

