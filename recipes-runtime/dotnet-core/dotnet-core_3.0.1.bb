###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 3.0.1 .Net Core runtime.
# Copyright Matthijs de Ridder 2019
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_3.0.1.inc
require recipes-runtime/dotnet-core/dotnet-core_3.x.x.inc

