###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 10.0.11 .Net runtime.
# Copyright Sequent Logic, LLC 2026
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_10.0.11.inc
require recipes-runtime/dotnet-core/dotnet-core_10.x.x.inc

