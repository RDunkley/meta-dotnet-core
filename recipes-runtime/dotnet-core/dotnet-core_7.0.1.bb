###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 7.0 .Net runtime.
# Copyright Sequent Logic 2022
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_7.0.1.inc
require recipes-runtime/dotnet-core/dotnet-core_7.x.x.inc

