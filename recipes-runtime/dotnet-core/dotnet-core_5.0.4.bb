###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 5.0.4 .Net Core runtime.
# Copyright Richard Dunkley 2020
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_5.0.4.inc
require recipes-runtime/dotnet-core/dotnet-core_5.x.x.inc

