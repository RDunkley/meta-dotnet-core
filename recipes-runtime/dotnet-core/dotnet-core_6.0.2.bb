###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.2 .Net runtime.
# Copyright Richard Dunkley 2022
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_6.0.2.inc
require recipes-runtime/dotnet-core/dotnet-core_6.x.x.inc

