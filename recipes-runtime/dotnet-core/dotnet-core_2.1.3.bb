###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version 2.1.3 .Net
# Core runtime.
# Copyright Richard Dunkley 2018
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_2.1.3.inc
require recipes-runtime/dotnet-core/dotnet-core_2.x.x.inc

