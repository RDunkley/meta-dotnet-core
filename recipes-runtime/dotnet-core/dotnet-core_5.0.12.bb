###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 5.0.12 .Net Core runtime.
# Copyright Richard Dunkley 2021
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_5.0.12.inc
require recipes-runtime/dotnet-core/dotnet-core_5.x.x.inc

