###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 10.0.14 .Net runtime.
# Copyright Richard Dunkley 2026
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_10.0.14.inc
require recipes-runtime/dotnet-core/dotnet-core_10.x.x.inc

