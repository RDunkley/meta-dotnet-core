# Copyright (C) 2020 Richard Dunkley
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-runtime/dotnet-core/dotnet-core_3.1.10.inc
require recipes-runtime/dotnet-core/dotnet-core_3.x.x.inc
