###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 11.0.0 .Net runtime.
# Copyright Richard Dunkley 2026
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_11.0.0.inc
require recipes-runtime/dotnet-core/dotnet-core_11.x.x.inc

