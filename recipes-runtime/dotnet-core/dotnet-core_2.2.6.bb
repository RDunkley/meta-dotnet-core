###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 2.2.6 .Net Core runtime.
# Copyright Richard Dunkley 2019
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_2.2.6.inc
require recipes-runtime/dotnet-core/dotnet-core_2.x.x.inc

