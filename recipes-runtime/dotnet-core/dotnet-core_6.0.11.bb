###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 6.0.11 .Net runtime.
# Copyright Sequent Logic 2022
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_6.0.11.inc
require recipes-runtime/dotnet-core/dotnet-core_6.x.x.inc

