###################################################################################################
# Contains the recipe to download the release binaries from Microsoft for the version
# 3.1.0 .Net Core runtime.
# Copyright Matthijs de Ridder 2019
###################################################################################################

require recipes-runtime/dotnet-core/dotnet-core_3.1.0.inc
require recipes-runtime/dotnet-core/dotnet-core_3.x.x.inc

