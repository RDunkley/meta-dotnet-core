###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Sequent Logic 2025
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_18.0.10821.2.inc
require recipes-devtools/vsdbg/vsdbg_18.x.inc
