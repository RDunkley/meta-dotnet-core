###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Richard Dunkley 2018
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_15.7.20426.1.inc
require recipes-devtools/vsdbg/vsdbg_15.x.inc

