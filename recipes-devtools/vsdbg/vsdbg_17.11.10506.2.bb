###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Richard Dunkley 2024
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_17.11.10506.2.inc
require recipes-devtools/vsdbg/vsdbg_17.x.inc
