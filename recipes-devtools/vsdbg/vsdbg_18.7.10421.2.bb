###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Richard Dunkley 2026
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_18.7.10421.2.inc
require recipes-devtools/vsdbg/vsdbg_18.x.inc
