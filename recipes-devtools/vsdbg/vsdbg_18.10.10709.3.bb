###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Sequent Logic, LLC 2026
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_18.10.10709.3.inc
require recipes-devtools/vsdbg/vsdbg_18.x.inc
