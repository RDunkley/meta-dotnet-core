###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Richard Dunkley 2020
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_17.0.10712.2.inc
require recipes-devtools/vsdbg/vsdbg_17.x.inc

