###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Sequent Logic 2022
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_17.4.11209.2.inc
require recipes-devtools/vsdbg/vsdbg_17.x.inc

