###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright Richard Dunkley 2019
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_16.2.10709.2.inc
require recipes-devtools/vsdbg/vsdbg_16.x.inc

