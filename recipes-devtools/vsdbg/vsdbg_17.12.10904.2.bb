###################################################################################################
# Contains the recipe to download the Visual Studio debugger from Microsoft to provide remote
# debugging from Visual Studio and Visual Studio Code.
# Copyright cjzzz 2024
# Auto-generated using meta_dotnet_core_gen
###################################################################################################

require recipes-devtools/vsdbg/vsdbg_17.12.10904.2.inc
require recipes-devtools/vsdbg/vsdbg_17.x.inc
